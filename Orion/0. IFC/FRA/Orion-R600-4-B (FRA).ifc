Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro de projet
Time: 2022-07-05T18:20:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Interface utilisateur alternative 19.2.20.24
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 05 18:20:36 2022 * Host: ENA567 * Database: C:\Users\admin\AppData\Local\Temp\{589E3FAF-5374-459F-834F-670F71593C9E}\ifc * Database version: 5507 * Database creation date: Tue Jul 05 18:20:36 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jul 05 18:20:36 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jul 05 18:20:36 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro de projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Autre - Adresse du projet: N° rue Ville, Etat Code postal; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro de projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: N° rue Ville, Etat Code postal; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro de projet

# IfcBuildingStorey, Niveau 2
LongName: Niveau 2; Elevation: 4000 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: M_Marqueur de niveau - Cercle: M_Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 4000 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 2; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet

# IfcBuildingElementProxy: Orion-R600-4-B, Orion-R600-4-B (FRA):Orion-R600-4-B:260934
In: Niveau 2
Type - Material: Aluminium, PC
Type - Autre - Catégorie: Luminaires; Adapté à un montage au plafond: oui; Adapté à un montage en saillie: oui; Adapté aux lampes de secours: oui; Adapté pour une transmission sans fil: oui; Alimentation: LED; Application: Espace intérieur; Avec appareil: oui; Avec capteur de lumière: oui; Avec détecteur de mouvement: oui; Avec source lumineuse: oui; Classe d'efficacité énergétique du illuminant selon l'étiquetage énergétique 2021: E; Classe d'efficacité énergétique du system selon l'étiquetage énergétique 2021: F; Classe de protection: I; Classe de protection [IP]: 20; Consommation d'énergie en mode marche 1000 h [kW/h]: 54.2; Constance des couleurs dans les ellipses de MacAdam [SDCM]: 3; Couleur du boîtier: blanc; Durée de vie L70/B10 à 25 °C [h]: 50000; Emission de lumière: dirècte; E-NR: 941300739; Entrée 1: poussoir / entrée slave; Entrée 2: poussoir / entrée slave; Flux lumineux [lm]: 4021; Flux lumineux éclairage de secours [lm]: 0; Fréquence de puissance [Hz]: 50-60; Garantie [j]: 5; Garantie sur batterie [j]: 0; Hauteur de montage max [m]: 10; Hauteur de montage minimum [m]: 2; Hauteur de montage optimale [m]: 2,5-3; Indice de rendu des couleurs (CRI): >85; Lampe de secours: avec 230 V; Largeur de portée max. [m]: 5; Lien: borne; Longueur de portée max. [m]: 1.5; Longueur maximale du câble de données «D» [km]: 1; Luminosité ajustable: oui; Marquage: CE; Mesure de l'effet stroboscopique: NA; Mesure du papillotement: NA; Nombre maximum de luminaires sur le disjoncteur de puissance: LS 10 A (C): 21 Pcs.; Nombre maximum de luminaires sur le disjoncteur de puissance: LS 16 A (C): 36 Pcs.; Nom de la famille: Orion-R600-4-B (FRA); Numéro d'article: 162882; Portée de présence max. [m]: 1.5; Programme d'origine: oui; Protection de la surface du boîtier: laqué; Puissance du système [W]: 54.2 W; Puissance en mode veille [W]: 1.2; Rayonnement directe-indirecte: 100% / 0%; Rendement [lm/W]: 85,316; Source lumineuse: LED; Télécomandable: avec Dongle IR-Bluetooth (IR-Connect), avec App Swisslux (iOS, Android); Température de couleur [K]: 4000; Type de montage: Montage apparent au plafond; Type de tension: AC; Unité de contrôle: TRIVALITE; Zone de détection: 360
Type - Contraintes - Elévation par défaut: 0 mm
Type - Cotes - Diamètre de la Lampe: 600 mm; Diamètre du symbole: 12 mm; Échelle des symboles: 50 mm
Type - Données d'identification - Commentaires du type: SWISSLUX; Nom du type: Orion-R600-4-B; URL: https://www.swisslux.ch/r/z8m
Type - Electricité - ADSK_Classification des charges: Beleuchtung; ADSK_Facteur de puissance: 0.95; ADSK_Nombre de phases: 1; ADSK_Nombre de phases numérique: 1; ADSK_Pleine puissance: 57.0526 W; ADSK_Puissance nominale: 54.2 W; ADSK_Voltage: 230 V; ADSK_Сourant: 0.248055 A
Type - Electrotechnique - Tension nominale: 230 V
Type - Matériaux et finitions - Matériau de la verrine: PC; Matériau du boîtier: Aluminium
Type - Photométriques - Angle de l'inclinaison: 90 deg; Couleur initiale: 0; Définition de la source d'éclairage (famille): Cercle+Distribution photométrique; Eclairement: 39.402 lx; Efficacité: 148.542 s3*lm/kg/m2; Emettre à partir du diamètre du cercle: 576 mm; Emettre la visibilité des formes dans le rendu: no; Facteur de perte de luminosité: 0; Facteur de perte de luminosité totale: 1; Fichier de distribution photométrique: Orion-R60-4-B_LDT.ies; Filtre de couleur: 16777215; Flux lumineux: 4600 lm; Gradation des changements de température de couleur de lampe: <Aucun>; Intensité initiale: 0; Intensité lumineuse: 366.056 cd; Puissance: 30.9677 W; Température initiale des couleurs: 4000 K
Pset_BuildingElementProxyCommon - Reference: Orion-R600-4-B
Autre - Famille: Orion-R600-4-B (FRA): Orion-R600-4-B; Famille et type: Orion-R600-4-B (FRA): Orion-R600-4-B; ID du type: Orion-R600-4-B (FRA): Orion-R600-4-B; Niveau de nomenclature: Niveau: Niveau 2; Type: Orion-R600-4-B (FRA): Orion-R600-4-B
Contraintes - Décalage: 0 mm; Niveau: Niveau: Niveau 2; Plan de construction: Plafond composé : Quadrillage 600 x 1200 mm
Cotes - Diamètre du tube vide: 20 mm; Volume: 0.0138414 m3
Données d'identification - Identifiant: 2
Electricité - Circuit - Données électriques: 230 V/1-57 VA
Phase de construction - Phase de création: Nouvelle construction
