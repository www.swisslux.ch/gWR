Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 2018_01
Time: 2022-07-05T15:14:06
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternativ-UI 19.2.20.24
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 05 15:14:06 2022 * Host: ENA567 * Database: C:\Users\admin\AppData\Local\Temp\{56308A15-C637-46BD-B878-65AEB35FA2F6}\ifc * Database version: 5507 * Database creation date: Tue Jul 05 15:14:06 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jul 05 15:14:06 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jul 05 15:14:06 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 2018_01
Phase: Projekt Status

# IfcSite, Default
RefLatitude: 48, 8, 15, 359802; RefLongitude: 11, 34, 47, 783432; RefElevation: 519 m
Sonstige - Auftraggeber: Bauherr; Kategorie: Projektinformationen; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektnummer: 2018_01; Projektstatus: Projekt Status; Verfasser eMail: E-Mail; Verfasser Firma 1: AUTODESK GmbH; Verfasser PLZ Ort: Ort; Verfasser Strasse: Adresse; Verfasser Telefon: Telefon; Verfasser URL: www.Autodesk.de/BIM
Text - Bauherr: AUTODESK; Baustellenort: BAUORT; Baustellenstraße: BAUSTRASSE 1; Einlagezahl: 123-45; Gerichtsbezirk: GERICHTSBEZIRK; Grundstücksnummer: GR; Katastralgemeinde: KG; Kundenadresse: KUNDENSTRASSE 1; Kundenort: KUNDENORT; Kundentelefon: 0000-00000-1; Kundenzusatz: KUNDENZUSATZ

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Sonstige - Kategorie: Projektinformationen; Auftraggeber: Bauherr; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektnummer: 2018_01; Projektstatus: Projekt Status; Verfasser eMail: E-Mail; Verfasser Firma 1: AUTODESK GmbH; Verfasser PLZ Ort: Ort; Verfasser Strasse: Adresse; Verfasser Telefon: Telefon; Verfasser URL: www.Autodesk.de/BIM
Text - Bauherr: AUTODESK; Baustellenort: BAUORT; Baustellenstraße: BAUSTRASSE 1; Einlagezahl: 123-45; Gerichtsbezirk: GERICHTSBEZIRK; Grundstücksnummer: GR; Katastralgemeinde: KG; Kundenadresse: KUNDENSTRASSE 1; Kundenort: KUNDENORT; Kundentelefon: 0000-00000-1; Kundenzusatz: KUNDENZUSATZ

# IfcBuildingStorey, Ebene -1
LongName: Ebene -1; Elevation: -3 m
Sonstige(Type) - Kategorie: Ebenen; Familienname: Ebene
ID-Daten(Type) - Typname: Ebene
Grafiken(Type) - Farbe: 16728128; Linienmuster: (Ebene); Linienstärke: 1; Symbol: Beschriftung Ebene Oberkante: Allgemein; Symbol bei Ende 1 Standard: no; Symbol bei Ende 2 Standard: yes
Abhängigkeiten(Type) - Basishöhe: Projekt-Basispunkt
Abhängigkeiten - Ansicht: -3 m
Abmessungen - Höhe für Berechnung: 1 m
Daten - FM Geschoss: UG 1
ID-Daten - Gebäudegeschoss: no; Name: Ebene -1; Tragwerk: no
Sonstige - Familie: Ebene: Ebene; Familie und Typ: Ebene: Ebene; Kategorie: Ebenen; Typ: Ebene: Ebene; Typ-ID: Ebene: Ebene

# IfcFlowTerminal: Orion-RE600-4-BS, Orion-RE600-4-BS (DEU):Orion-RE600-4-BS:2429955
In: Ebene -1
Type - Material: Aluminium, PC
Type - Abhängigkeiten - Vorgabe-Ansicht: 0 m
Type - Abmessungen - Durchmesser der Lampe: 0.6 m; Durchmesser des Symbols: 0.012 m; Symbolskala: 0.05 m
Type - Elektro - ADSK_Anzahl der Phasen: 1; ADSK_Anzahl der Phasen numerisch: 1; ADSK_Lastklassifizierung: Beleuchtung; ADSK_Leistungsfaktor: 0.95; ADSK_Scheinleistung: 58.7368 W; ADSK_Spannung: 230 V; ADSK_Strom: 0.255378 A; ADSK_Wattzahl: 55.8 W
Type - Elektrotechnik - Spannungsversorgung: 230 V
Type - Fotometrische Daten - Anfängliche Farbtemperatur: 4000 K; Anfangsfarbe: 0; Anfangsintensität: 0; Beleuchtungsstärke: 39.402 lx; Datei für fotometrisches Netz: Orion-RE60-4-BS_LDT.ies; Emissionsform beim Rendern sichtbar: no; Farbfilter: 16777215; Farbtemperaturverschiebung bei Dämpfen der Lampe: <Keine Auswahl>; Lichtquellendefinition (Familie): Kreis+Fotometrisches Netz; Lichtstärke: 366.056 cd; Lichtstrom: 4600 lm; Lichtverlustfaktor: 0; Lichtverlustfaktor insgesamt: 1; Neigungswinkel: 90 deg; Von Kreisdurchmesser aussenden: 0.576 m; Wattzahl: 30.9677 W; Wirkungsgrad: 148.542 s3*lm/kg/m2
Type - ID-Daten - Typenkommentare: SWISSLUX; Typname: Orion-RE600-4-BS; URL: https://www.swisslux.ch/r/lCU
Type - Materialien und Oberflächen - Werkstoff der Abdeckung: PC; Werkstoff des Gehäuses: Aluminium
Type - Sonstige - Kategorie: Leuchten; Anschlussart: Steckklemme; Ansprechhelligkeit einstellbar: ja; Artikelnummer: 162891; Betriebsgerät: LED Betriebsgerät; Betriebstemperatur [°C]: 0…35; Effizienz ab Diffusor [lm/W]: 82,87; Eingang 1: Tastereingang / Slaveeingang; Eingang 2: Tastereingang / Slaveeingang; Einsatzgebiet: Innenraum; Energieeffizienzklasse Leuchte/System nach Energieetikette 2021: G; Energieeffizienzklasse Leuchtmittel nach Energieetikette 2021: E; E-NR: 941400599; Erfassungsbereich [°]: 360; Familienname: Orion-RE600-4-BS (DEU); Farbkonsistenz in MacAdam-Ellipsen [SDCM]: 3; Farbtemperatur [K]: 4000; Farbwiedergabe-Index (CRI): >85; Fernbedienbar: Fernbedienbar über IR-Bluetooth Dongle (IR-Connect), mit Swisslux App (iOS, Android); Flimmer-Messgrösse: NA; Garantie [j]: 5; Garantie auf Akku [j]: 2; Geeignet für Deckenmontage: ja; Geeignet für den Einbau in Isolation: nein; Geeignet für drahlose Übertragung: Ja; Geeignet für Einbaumontage: ja; Geeignet für Notlicht: Ja; Gehäusefarbe: weiss; Lebensdauer L70B10 bei 25°C [h]: 50000; Leistungsaufnahme 1000 h [kW/h]: 55.8; Leuchtmittel: LED; Lichtanteil direkt-indirekt: 100% / 0%; Lichtaustritt: direkt; Lichtstrom ab Diffusor [lm]: 4021; Lichtstrom bei Notlicht ab Diffusor [lm]: 450; Maximale Anzahl Leuchten an Leitungsschutzschalter: LS 10 A (C): 21 Stk.; Maximale Anzahl Leuchten an Leitungsschutzschalter: LS 16 A (C): 36 Stk.; Maximale Länge Datendraht «D» [km]: 1; Messgrösse für Stroboskop-Effekte: NA; Mit Betriebsgerät: ja; Mit Bewegungsmelder: ja; Mit Leuchtmittel: ja; Mit Lichtsensor: ja; Montagehöhe empfohlen [m]: 2,5-3; Montagehöhe maximum [m]: 10; Montagehöhe minimum [m]: 2; Montagekategorie: Decken-Einbau; Nennleistung [W]: 55.8 W; Netzfrequenz [Hz]: 50-60; Notlicht: 1h Notlichtbetrieb mit integriertem Akku; Oberflächenschutz Gehäuse: lackiert; Prüfzeichen: CE; Reichweite beidirektem Draufzugehen [m]: 1.5; Reichweite bei seitlichem Vorbeigehen [m]: 5; Reichweite für sitzende Personen (Präsenz) [m]: 1.5; Schutzart [IP]: 20; Schutzklasse: I; Spannungsart: AC; Standbyleistung [W]: 2.8; Steuerelemente: TRIVALITE; Werksprogramm: Ja
Pset_DistributionFlowElementCommon - Reference: Orion-RE600-4-BS
Abhängigkeiten - Arbeitsebene: Basisdecke : Standard; Ebene: Ebene: Ebene -1; Versatz: 0 m
Abmessungen - Durchmesser der leerrohr: 0.02 m; Volumen: 0.0162888 m3
Elektro - Stromkreise - Elektrische Daten: 230 V/1-59 VA
ID-Daten - Kennzeichen: 4
Phasen - Phase erstellt: Phase 1
Sonstige - Bauteillistenebene: Ebene: Ebene -1; Familie: Orion-RE600-4-BS (DEU): Orion-RE600-4-BS; Familie und Typ: Orion-RE600-4-BS (DEU): Orion-RE600-4-BS; Typ: Orion-RE600-4-BS (DEU): Orion-RE600-4-BS; Typ-ID: Orion-RE600-4-BS (DEU): Orion-RE600-4-BS
