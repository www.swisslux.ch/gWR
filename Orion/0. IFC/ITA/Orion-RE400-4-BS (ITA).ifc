Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numero del progetto
Time: 2022-07-05T17:34:41
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.20.24
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 05 17:34:41 2022 * Host: ENA567 * Database: C:\Users\admin\AppData\Local\Temp\{392E9F4B-64F1-42A5-8945-1401E20BED82}\ifc * Database version: 5507 * Database creation date: Tue Jul 05 17:34:41 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jul 05 17:34:41 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jul 05 17:34:41 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numero del progetto
LongName: Nome del progetto; Phase: Stato del progetto

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data di consegna; Indirizzo del progetto: Via ## Città (Provincia) C.A.P.; Nome del cliente: Proprietario; Nome del progetto: Nome del progetto; Numero del progetto: Numero del progetto; Stato del progetto: Stato del progetto
Dati identità - Workset: Informazioni progetto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data di consegna; Indirizzo del progetto: Via ## Città (Provincia) C.A.P.; Nome del cliente: Proprietario; Nome del progetto: Nome del progetto; Numero del progetto: Numero del progetto; Stato del progetto: Stato del progetto
Dati identità - Workset: Informazioni progetto

# IfcBuildingStorey, Livello 1
LongName: Livello 1; Elevation: 0 mm
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Centro; Simbolo: M_Estremità del livello - Cerchio: M_Estremità del livello - Cerchio; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Estremità 8 mm; Famiglia e tipo: Livello: Estremità 8 mm; ID tipo: Livello: Estremità 8 mm; Tipo: Livello: Estremità 8 mm
Dati identità - Nome: Livello 1; Piano edificio: yes; Strutturale: no; Workset: Griglie e livelli condivisi
Dimensioni - Altezza di calcolo: 0 mm
Vincoli - Quota altimetrica: 0 mm
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Estremità 8 mm; Workset: Tipi di livello

# IfcBuildingElementProxy: Orion-RE400-4-BS, Orion-RE400-4-BS (ITA):Orion-RE400-4-BS:295146
In: Livello 1
Type - Material: Alluminio, PC
Type - Altro - Categoria: Apparecchi per illuminazione; Adatto per fissaggio a soffitto: si; Adatto per luce d'emergenza: si; Adatto per montaggio a incasso: si; Adatto per trasmissione senza fili: si; Alimentazione: LED; Altezza di montaggio massima [m]: 10; Altezza di montaggio minima [m]: 2; Altezza di montaggio ottimale [m]: 2,5-3; Apparecchio cablato: si; Applicazione: Ambiente interno; Certificazione: CE; Classe di efficienza energetica di illuminante per l'etichettatura energetica 2021: E; Classe di efficienza energetica di sytema per l'etichettatura energetica 2021: G; Classe isolamento: I; Codice articolo: 162887; Coerenza dei colori in ellissi di MacAdam [SDCM]: 3; Collegamento: morsetto; Colore dell'apparecchio: bianco; Con fotocellula: si; Con lampada inclusa: si; Con sensore di movimento: si; Consumo di energia in modo acceso 1000 h [kW/h]: 36; Corpo illuminante: LED; Efficienza [lm/W]: 77,769; Emissione della luce diretta-indiretta: 100% / 0%; E-NR: 941400499; Entrata 1: Tasto / entrata slave; Entrata 2: Tasto / entrata slave; Flusso luminoso [lm]: 2434,5; Flusso luminoso luce d'emergenza [lm]: 450; Frequenza di alimentazione [Hz]: 50-60; Garanzia [j]: 5; Garanzia sulla batteria[j]: 2; Grado di protezione [IP]: 20; Idoneo ad essere ricoperto con materiali isolanti: no; Indice di resa cromatica (CRI): >85; Luce d'emergenza: 1 h grazie alla batteria integrata; Luminosità regolabile: si; Lunghezza massima del filo dati «D» [km]: 1; Max. gamma di presenza [m]: 1.5; Max. portata da un lato [m]: 5; Max. portata frontale [m]: 1.5; Metrica dell'effetto stroboscopico: NA; Metrica dello sfarfallio: NA; Nome famiglia: Orion-RE400-4-BS (ITA); Numero massimo di lampade sul disgiuntore di potenza: LS 10 A (C): 21 Pc.; Numero massimo di lampade sul disgiuntore di potenza: LS 16 A (C): 36 Pc.; Potenza in modo stand-by [W]: 2.8; Potenza totale [W]: 36 W; Programma di fabbrica: si; Protezione superficiale alloggiamento: laccato; Teleomandabile: con IR-Bluetooth Dongle (IR-Connect), con App Swisslux (iOS, Android); Temperatura ambiente nominale [°C]: 0…35; Temperatura di colore [K]: 4000; Tipo di montaggio, luogo di montaggio, dati: Montaggio sottomuro a soffitto; Tipo di tensione: AC; Unità di controllo: TRIVALITE; Uscita della luce: diretta; Vita utile misurazioni L70/B10 a 25 °C [h]: 50000; Zona di rilevamento: 360
Type - Dati identità - Commenti sul tipo: SWISSLUX; Modificato da: anton.ohamuk; Nome del tipo: Orion-RE400-4-BS; URL: https://www.swisslux.ch/r/7Qs; Workset: Famiglia : Apparecchi per illuminazione : Orion-RE400-4-BS (ITA)
Type - Dimensioni - Diametro della lampada: 400 mm; Diametro del simbolo: 8 mm; Scala dei simboli: 50 mm
Type - Elettrico - ADSK_Classificazione dei carichi: Beleuchtung; ADSK_Fattore di potenza: 0.95; ADSK_Numero di fasi: 1; ADSK_Numero di fasi numerico: 1; ADSK_Piena potenza: 37.8947 W; ADSK_Potenza nominale: 36 W; ADSK_Tensione: 230 V; ADSK_Сorrente: 0.16476 A
Type - Fotometrica - Angolo inclinazione: 90 deg; Colore iniziale: 0; Definizione sorgente d'illuminazione (famiglia): Cerchio+Diagramma fotometrico; Efficacia: 148.542 s3*lm/kg/m2; Emetti da diametro cerchio: 376 mm; Fattore di perdita di illuminazione: 0; Fattore totale di perdita di illuminazione: 1; File diagramma fotometrico: Orion-RE40-4-BS_LDT.ies; Filtro dei colori: 16777215; Flusso luminoso: 2450 lm; Illuminanza: 20.9858 lx; Intensità iniziale: 0; Intensità luminosa: 194.965 cd; Rendi la forma visibile nel rendering: no; Temperatura colore iniziale: 4000 K; Variazione temperatura colore lampada con luminosità attenuata: <Nessuno>; Watt: 16.4937 W
Type - Ingegneria elettrica - Tensione nominale: 230 V
Type - Materiali e finiture - Materiale della copertura: PC; Materiale della custodia: Alluminio
Type - Vincoli - Prospetto di default: 0 mm
Pset_BuildingElementProxyCommon - Reference: Orion-RE400-4-BS
Altro - Famiglia: Orion-RE400-4-BS (ITA): Orion-RE400-4-BS; Famiglia e tipo: Orion-RE400-4-BS (ITA): Orion-RE400-4-BS; ID tipo: Orion-RE400-4-BS (ITA): Orion-RE400-4-BS; Livello abaco: Livello: Livello 1; Tipo: Orion-RE400-4-BS (ITA): Orion-RE400-4-BS
Dati identità - Contrassegno: 22; Workset: Workset1
Dimensioni - Diametro del tubo vuoto: 20 mm; Volume: 0.00737373 m3
Elettrico - Circuiti - Dati elettrici: 230 V/1-38 VA
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Livello: Livello: Livello 1; Offset: 0 mm; Piano di lavoro: Pavimento : Pavimento generico - 400 mm
